File: HIGH LEVEL OVERVIEW.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Commit after Review
Other:
- company: (none) -> Exact Technology
- title: (none) -> EM3 Fixture
